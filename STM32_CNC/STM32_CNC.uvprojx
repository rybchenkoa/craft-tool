# Keil uVision project STM32_CNC.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F100C4 STMicroelectronics
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M3") CLOCK(24000000) ELITTLE
  output: STM32_CNC +hex
  c flags: Optim=4 oTime=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: STM32_CNC.sct
  group Source Group 1
    ./: main.cpp hal_0.h gpio_use.h fifo.h motor.h USART_module.h cos_table.cpp led.h common.h mover.h packets.h sys_timer.h float16.h
  group ::Device
    RTE/Device/STM32F100C4/: RTE_Device.h startup_stm32f10x_ld_vl.s system_stm32f10x.c
    E:/Development/Keil/ARM/PACK/Keil/STM32F1xx_DFP/1.0.2/RTE_Driver/: GPIO_STM32F10x.c
software components: CMSIS:CORE 3.20.0, Device:GPIO 1.01.0, Device:Startup 1.0.0
